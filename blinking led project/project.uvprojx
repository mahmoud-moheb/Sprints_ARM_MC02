# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\COTS\Services;..\COTS\MCAL\ClockControl;..\COTS\MCAL\SysTick;..\COTS\MCAL\GPIO;..\COTS\HAL\Led;..\COTS\MCAL\Interrupt
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x40ffffff
  group Source Group 1
    ./: main.c
    ../COTS/MCAL/ClockControl/: ClockControl_Program.c
    ../COTS/MCAL/GPIO/: GPIO_Program.c
    ../COTS/MCAL/SysTick/: SysTick_Program.c
    ../COTS/HAL/Led/: Led_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
